# Keil uVision project emFile_Example01_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: emFile_Example01_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h emFile.h emFile_ConfigMMC_SPI.c emFile_MMC_HW_SPI.c emFile_PM.c LCD.c LCD.h LCD_PM.c emFile_SPI0.c emFile_SPI0.h emFile_SPI0_PM.c emFile_SPI0_INT.c emFile_SPI0_PVT.h emFile_mosi0.c emFile_mosi0.h emFile_mosi0_aliases.h emFile_Clock_1.c emFile_Clock_1.h emFile_miso0.c emFile_miso0.h emFile_miso0_aliases.h emFile_sclk0.c emFile_sclk0.h emFile_sclk0_aliases.h emFile_SPI0_CS.c emFile_SPI0_CS.h emFile_SPI0_CS_aliases.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h cy_em_eeprom.c cy_em_eeprom.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: emFile_Example01_PSoC3lib (library)
  c flags: Optimize=5
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
